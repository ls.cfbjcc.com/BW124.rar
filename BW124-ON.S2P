!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5244A)
! VAR MeasDate=9/14/2012 3:38:39 PM
! VAR NAME=126015-1 2
! VAR FILENAME=126015-1 2.S2P
! VAR DATE=9/14/2012 3:38:39 PM
! VAR PHYS_PORTS=1,2
# Hz S MA R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 100 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -31.37 dB at 19.95 GHz (marker M1); lowest = -94.0 dB at 6.418 GHz (marker M2)
!   lowest |S11| = -23.6 dB at 14.05 GHz (marker M3), VSWR 1.14, Z = 56.4 + j3.02 ohm
!   |S11| at or under -10 dB: start of sweep to 5.417 GHz; 5.427 GHz to 5.48 GHz (53.77 MHz wide, 0.986 % of centre); 11.1 GHz to 15.73 GHz (4.633 GHz wide, 34.5 % of centre)
!   |S22| runs from -11.9 to -9.0 dB; largest |S21 - S12| = 0.0027
!   S11 on the Smith chart (normalised r, x): 100 MHz: 1.23, -0.04; 6.518 GHz: 0.51, -0.22; 11.94 GHz: 0.64, +0.24; 15.27 GHz: 1.04, -0.48; 17.59 GHz: 0.30, -0.42; 20 GHz: 0.12, -0.07
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  -19.8  -63.4  -58.2  -11.5
! 323.9 MHz  -20.1  -68.3  -60.6  -11.5
! 721.9 MHz  -19.7  -62.7  -60.9  -11.6
! 945.8 MHz  -19.1  -62.2  -65.9  -11.7
! 2.239 GHz  -15.4  -59.5  -63.2  -11.8
! 3.433 GHz  -12.8  -75.3  -71.1  -11.8
! 4.13 GHz  -11.6  -60.1  -71.9  -11.8
! 5.1 GHz  -10.3  -71.5  -67.5  -11.9
! 5.622 GHz  -9.8  -70.1  -64.9  -11.9
! 6.244 GHz  -9.3  -58.6  -68.0  -11.9
! 6.418 GHz  -9.2  -94.0  -61.0  -11.9
! 6.518 GHz  -9.1  -61.9  -60.7  -11.8
! 6.742 GHz  -9.0  -73.6  -58.7  -11.8
! 10.05 GHz  -9.0  -54.7  -52.8  -11.7
! 11.94 GHz  -11.6  -46.9  -46.5  -11.4
! 13.38 GHz  -18.7  -41.7  -42.1  -11.1
! 14.05 GHz  -23.6  -39.8  -39.9  -11.0
! 15.27 GHz  -12.8  -36.8  -36.2  -10.6
! 16.69 GHz  -6.4  -33.9  -33.7  -10.1
! 17.59 GHz  -4.4  -32.9  -32.7  -10.0
! 19.95 GHz  -2.2  -31.4  -31.7  -9.0
! 20 GHz  -2.2  -31.5  -31.4  -9.1
